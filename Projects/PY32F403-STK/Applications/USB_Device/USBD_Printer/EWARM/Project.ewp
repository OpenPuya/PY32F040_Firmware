# IAR project Project.ewp, settings and files
configuration Project (ARM, debug)
  General.OGChipSelectEditMenu: PY32F403xD Puya PY32F403xD
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; PY32F403xD
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Drivers\BSP\PY32F403xx_Start_Kit; ..\..\..\..\..\..\Drivers\CMSIS\Device\PUYA\PY32F4xx\Include; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\PY32F4xx_HAL_Driver\Inc; ..\Inc; ..\..\..\..\..\..\Middlewares\Third_Party\CherryUSB\class\cdc; ..\..\..\..\..\..\Middlewares\Third_Party\CherryUSB\class\printer; ..\..\..\..\..\..\Middlewares\Third_Party\CherryUSB\common; ..\..\..\..\..\..\Middlewares\Third_Party\CherryUSB\core; ..\..\..\..\..\..\Middlewares\Third_Party\CherryUSB\port
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: py32f403xD_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/BSP/PY32F403xx_Start_Kit
    ../../../../../../Drivers/BSP/PY32F403xx_Start_Kit/: py32f403xx_Start_Kit.c
  group Drivers/CherryUSB
    ../../../../../../Middlewares/Third_Party/CherryUSB/port/: usb_dc_py32.c
    ../../../../../../Middlewares/Third_Party/CherryUSB/core/: usbd_core.c
    ../../../../../../Middlewares/Third_Party/CherryUSB/class/printer/: usbd_printer.c
  group Drivers/CMSIS
    ../Src/: system_py32f4xx.c
  group Drivers/PY32F4xx_HAL_Driver
    ../../../../../../Drivers/PY32F4xx_HAL_Driver/Src/: py32f4xx_hal.c py32f4xx_hal_cortex.c py32f4xx_hal_dma.c py32f4xx_hal_gpio.c py32f4xx_hal_pwr.c py32f4xx_hal_pwr_ex.c py32f4xx_hal_rcc.c py32f4xx_hal_rcc_ex.c py32f4xx_hal_uart.c
  group Example/EWARM
    ./: startup_py32f403xx.s
  group Example/User
    ../Src/: main.c py32f4xx_hal_msp.c py32f4xx_it.c usbd_printer_if.c
